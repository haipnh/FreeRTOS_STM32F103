# Keil uVision project FirstProj.uvprojx, settings and files
target USART1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: USART1
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\..\StdPeriph_Driver;..\..\StdPeriph_Driver\STM32F10x_StdPeriph_Driver\inc;..\..\StdPeriph_Driver\CMSIS\CM3\CoreSupport;..\..\PeriphMod_Driver\inc;..\..\FreeRTOSv10\include;..\..\FreeRTOSv10\customStartup;..\..\FreeRTOSv10\portable\RVDS\ARM_CM3;..\..\FreeRTOS_Task\inc;.\User
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ../../StdPeriph_Driver/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../../StdPeriph_Driver/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ../../FreeRTOSv10/customStartup/: STM32F10x.s
  group StdPeriph_Driver
    ../../StdPeriph_Driver/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_usart.c
  group PeriphMod_Driver
    ../../PeriphMod_Driver/src/: TIMER_DELAY.c LCD_20x4.c
  group FreeRTOS
    ../../FreeRTOSv10/: list.c queue.c tasks.c
    ../../FreeRTOSv10/portable/MemMang/: heap_2.c
    ../../FreeRTOSv10/portable/RVDS/ARM_CM3/: port.c
  group FreeRTOS_Task
    ../../FreeRTOS_Task/src/: serial.c
  group User
    ./User/: main.c
