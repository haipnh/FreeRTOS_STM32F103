# Keil uVision project Dev_Proj.uvprojx, settings and files
target Dev_Proj (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Dev_Proj
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\StdPeriph_Driver;..\StdPeriph_Driver\CMSIS\CM3\CoreSupport;..\StdPeriph_Driver\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\StdPeriph_Driver\STM32F10x_StdPeriph_Driver\inc;..\FreeRTOSv10\customStartupConfig;..\FreeRTOSv10\include;..\FreeRTOSv10\portable\RVDS;..\PeriphMod_Driver\LCD_20x4\inc;..\PeriphMod_Driver\TIMER_DELAY\inc;..\PeriphMod_Driver\IC_74595\inc;..\PeriphMod_Driver\DHT11\inc;.\Tasks\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CM3_CMSIS
    ../StdPeriph_Driver/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../FreeRTOSv10/customStartupConfig/: STM32F10x.s
    ../StdPeriph_Driver/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group StdPeriph_Driver
    ../StdPeriph_Driver/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_spi.c stm32f10x_wwdg.c
  group PeriphMod_Driver
    ../PeriphMod_Driver/LCD_20x4/src/: LCD_20x4.c
    ../PeriphMod_Driver/IC_74595/src/: IC_74595.c
    ../PeriphMod_Driver/TIMER_DELAY/src/: TIMER_DELAY.c
    ../PeriphMod_Driver/DHT11/src/: DHT11.c
  group FreeRTOS_v10
    ../FreeRTOSv10/: list.c queue.c tasks.c timers.c
    ../FreeRTOSv10/portable/MemMang/: heap_2.c
    ../FreeRTOSv10/portable/RVDS/: port.c
  group FreeRTOS_Tasks
    ./Tasks/src/: BlinkLedTasks.c LCD20x4Task.c
  group User
    ./: main.c
